# Keil uVision project Project.uvprojx, settings and files
target STM32F40_41xxx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F40_41xxx +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,ARM_MATH_CM4
  c misc: --C99
  c include: ..\..\..\Micrium\uC-CPU;..\..\..\Micrium\uC-LIB;..\..\..\Micrium\uCOS-III;..\..\..\Micrium\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\Micrium\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\Micrium\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\Micrium\uCOS-III\Source;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\MDK-ARM;..\;..\BSP;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c
  group APP
    ../APP/: os_app_hooks.c Task00_MainProcess.c Task01_Name.c
  group uC/LIB
    ../../../Micrium/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../Micrium/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../../Micrium/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III Port
    ../../../Micrium/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group uC/CPU
    ../../../Micrium/uC-CPU/: cpu_core.c
    ../../../Micrium/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c bsp.c
  group CMSIS
    ../: system_stm32f4xx.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/5.0.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_dbgmcu.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_crc.c misc.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_rtc.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Doc
    ../: readme.c
software components: CMSIS:CORE 5.0.0
